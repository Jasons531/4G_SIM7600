# Keil uVision project SIM7600.uvprojx, settings and files
target SIM7600 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: SIM7600 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../Drivers/CMSIS/Include;..\contiki-3.0\cpu\arm\stm32f103;..\contiki-3.0\core\sys;..\contiki-3.0\core;..\contiki-3.0\cpu\stm32w108
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_tim.c stm32f2xx_hal_uart.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_spi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Application/User
    ../Src/: stm32f2xx_it.c gpio.c main.c usart.c stm32f2xx_hal_msp.c delay.c dma.c spi.c sim7600.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group contiki_clock
    ../contiki-3.0/cpu/arm/stm32f103/: clock.c
  group contiki_sys
    ../contiki-3.0/core/sys/: autostart.c process.c rtimer.c timer.c etimer.c ctimer.c stimer.c
    ../contiki-3.0/cpu/stm32w108/: rtimer-arch.c
software components: CMSIS:CORE 4.1.0
